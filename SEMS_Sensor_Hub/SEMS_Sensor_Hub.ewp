# IAR project SEMS_Sensor_Hub.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; S132; NRF_SD_BLE_API_VERSION=3; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; SOFTDEVICE_PRESENT; NRF52832; NRF52; SWI_DISABLE0
  ICCARM.CCIncludePath2: Application; Application\SEMS_Libs; Application\SEMS_Libs\nanobp; Application\SEMS_Utils; Application\SEMS_ProtoBuf; Application\SEMS_Module; Application\SEMS_Module\SEMS_Actuator\SEMS_IR_Encoder; Application\SEMS_Module\SEMS_Actuator; Application\SEMS_Module\SEMS_Sensor; Application\SEMS_BLE_Services; $NRF5_SDK12$\examples\bsp; $NRF5_SDK12$\components; $NRF5_SDK12$\components\toolchain; $NRF5_SDK12$\components\toolchain\cmsis\include; $NRF5_SDK12$\components\softdevice\common\softdevice_handler; $NRF5_SDK12$\components\softdevice\s132\headers; $NRF5_SDK12$\components\softdevice\s132\headers\nrf52; $NRF5_SDK12$\components\libraries\twi; $NRF5_SDK12$\components\libraries\button; $NRF5_SDK12$\components\libraries\crc16; $NRF5_SDK12$\components\libraries\crc32; $NRF5_SDK12$\components\libraries\csense; $NRF5_SDK12$\components\libraries\csense_drv; $NRF5_SDK12$\components\libraries\experimental_section_vars; $NRF5_SDK12$\components\libraries\fds; $NRF5_SDK12$\components\libraries\fifo; $NRF5_SDK12$\components\libraries\fstorage; $NRF5_SDK12$\components\libraries\hardfault; $NRF5_SDK12$\components\libraries\hci; $NRF5_SDK12$\components\libraries\led_softblink; $NRF5_SDK12$\components\libraries\log; $NRF5_SDK12$\components\libraries\log\src; $NRF5_SDK12$\components\libraries\low_power_pwm; $NRF5_SDK12$\components\libraries\mailbox; $NRF5_SDK12$\components\libraries\mem_manager; $NRF5_SDK12$\components\libraries\pwm; $NRF5_SDK12$\components\libraries\scheduler; $NRF5_SDK12$\components\libraries\sensorsim; $NRF5_SDK12$\components\libraries\slip; $NRF5_SDK12$\components\libraries\timer; $NRF5_SDK12$\components\libraries\twi; $NRF5_SDK12$\components\libraries\uart; $NRF5_SDK12$\components\libraries\util; $NRF5_SDK12$\components\device; $NRF5_SDK12$\components\drivers_nrf; $NRF5_SDK12$\components\drivers_nrf\common; $NRF5_SDK12$\components\drivers_nrf\nrf_soc_nosd; $NRF5_SDK12$\components\drivers_nrf\clock; $NRF5_SDK12$\components\drivers_nrf\gpiote; $NRF5_SDK12$\components\drivers_nrf\uart; $NRF5_SDK12$\components\drivers_nrf\hal; $NRF5_SDK12$\components\drivers_nrf\timer; $NRF5_SDK12$\components\drivers_nrf\delay; $NRF5_SDK12$\components\drivers_nrf\twi_master; $NRF5_SDK12$\components\ble\ble_dtm; $NRF5_SDK12$\components\ble\ble_racp; $NRF5_SDK12$\components\ble\common; $NRF5_SDK12$\components\ble\ble_advertising; $NRF5_SDK12$\components\ble\peer_manager; $NRF5_SDK12$\external\segger_rtt; $NRF5_SDK12$\examples\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: Application; $NRF5_SDK12$\examples\bsp; $NRF5_SDK12$\components; $NRF5_SDK12$\components\toolchain; $NRF5_SDK12$\components\toolchain\cmsis\include; $NRF5_SDK12$\components\softdevice\common\softdevice_handler; $NRF5_SDK12$\components\softdevice\s132\headers; $NRF5_SDK12$\components\softdevice\s132\headers\nrf52; $NRF5_SDK12$\components\libraries; $NRF5_SDK12$\components\libraries\util; $NRF5_SDK12$\components\libraries\sensorsim; $NRF5_SDK12$\components\libraries\button; $NRF5_SDK12$\components\libraries\timer; $NRF5_SDK12$\components\libraries\fstorage; $NRF5_SDK12$\components\libraries\fds; $NRF5_SDK12$\components\libraries\experimental_section_vars; $NRF5_SDK12$\components\libraries\log; $NRF5_SDK12$\components\libraries\log\src; $NRF5_SDK12$\components\device; $NRF5_SDK12$\components\drivers_nrf; $NRF5_SDK12$\components\drivers_nrf\common; $NRF5_SDK12$\components\drivers_nrf\nrf_soc_nosd; $NRF5_SDK12$\components\drivers_nrf\clock; $NRF5_SDK12$\components\drivers_nrf\gpiote; $NRF5_SDK12$\components\drivers_nrf\hal; $NRF5_SDK12$\components\drivers_nrf\delay; $NRF5_SDK12$\components\ble\common; $NRF5_SDK12$\components\ble\ble_advertising; $NRF5_SDK12$\components\ble\peer_manager; $NRF5_SDK12$\external\segger_rtt
  OBJCOPY.OOCOutputFile: SEMS_Sensor_Hub.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: iar_s132_nrf52832_xxaa.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Application
    Application/: main.c sdk_config.h sems.h test_sensor.c test_sensor.h
  group Board Support
    $NRF5_SDK12$/examples/bsp/: bsp.c bsp_btn_ble.c
  group Device
    $NRF5_SDK12$/components/toolchain/iar/: iar_startup_nrf52.s
    $NRF5_SDK12$/components/toolchain/: system_nrf52.c
  group nanopb
    Application/SEMS_Libs/nanobp/: pb.h pb_common.c pb_common.h pb_decode.c pb_decode.h pb_encode.c pb_encode.h
  group nRF_BLE
    $NRF5_SDK12$/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    $NRF5_SDK12$/components/ble/ble_advertising/: ble_advertising.c
    $NRF5_SDK12$/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_Drivers
    $NRF5_SDK12$/components/drivers_nrf/clock/: nrf_drv_clock.c
    $NRF5_SDK12$/components/drivers_nrf/common/: nrf_drv_common.c
    $NRF5_SDK12$/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    $NRF5_SDK12$/components/drivers_nrf/timer/: nrf_drv_timer.c
    $NRF5_SDK12$/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    $NRF5_SDK12$/components/drivers_nrf/uart/: nrf_drv_uart.c
    $NRF5_SDK12$/components/drivers_nrf/nrf_soc_nosd/: nrf_error.h nrf_nvic.c nrf_nvic.h nrf_soc.c nrf_soc.h
  group nRF_Libraries
    $NRF5_SDK12$/components/libraries/button/: app_button.c
    $NRF5_SDK12$/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    $NRF5_SDK12$/components/libraries/fifo/: app_fifo.c
    $NRF5_SDK12$/components/libraries/pwm/: app_pwm.c app_pwm.h
    $NRF5_SDK12$/components/libraries/scheduler/: app_scheduler.c app_scheduler_serconn.c
    $NRF5_SDK12$/components/libraries/timer/: app_timer.c
    $NRF5_SDK12$/components/libraries/twi/: app_twi.c
    $NRF5_SDK12$/components/libraries/crc16/: crc16.c
    $NRF5_SDK12$/components/libraries/fds/: fds.c
    $NRF5_SDK12$/components/libraries/fstorage/: fstorage.c
    $NRF5_SDK12$/components/libraries/hardfault/: hardfault_implementation.c
    $NRF5_SDK12$/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    $NRF5_SDK12$/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    $NRF5_SDK12$/external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    $NRF5_SDK12$/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group SEMS_BLE_Services
    Application/SEMS_BLE_Services/: ble_action_service.c ble_action_service.h ble_battery_service.c ble_battery_service.h ble_sensor_service.c ble_sensor_service.h ble_services.c ble_services.h
  group SEMS_Module
    Application/SEMS_Module/: sems_module.c sems_module.h sensor_handler.c sensor_handler.h
  group SEMS_Module/SEMS_Actuator
    Application/SEMS_Module/SEMS_Actuator/: sems_actuator.c sems_actuator.h sems_ir_actuator.c sems_ir_actuator.h sems_TEMPLATE_actuator.c sems_TEMPLATE_actuator.h
  group SEMS_Module/SEMS_Actuator/SEMS_IR_Encoder
    Application/SEMS_Module/SEMS_Actuator/SEMS_IR_Encoder/: sems_ir_nec_encoder.c sems_ir_nec_encoder.h sems_ir_raw_encoder.c sems_ir_raw_encoder.h
  group SEMS_Module/SEMS_Sensor
    Application/SEMS_Module/SEMS_Sensor/: GPIOSensor.c GPIOSensor.h HTU21D.c HTU21D.h sems_sensor.c sems_sensor.h TemplateSensor.c TemplateSensor.h TSL2561.c TSL2561.h
  group SEMS_ProtoBuf
    Application/SEMS_ProtoBuf/: sems.pb.c sems.pb.h
  group SEMS_Utils
    Application/SEMS_Utils/: linkedlist.c linkedlist.h
